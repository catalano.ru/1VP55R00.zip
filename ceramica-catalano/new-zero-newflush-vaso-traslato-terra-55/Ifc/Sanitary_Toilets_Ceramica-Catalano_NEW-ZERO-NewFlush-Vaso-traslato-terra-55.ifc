Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Toilets_Ceramica-Catalano_NEW-ZERO-NewFlush-Vaso-traslato-terra-55.ifc
Time: 2023-03-23T10:17:46
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: NEW ZERO NewFlush Vaso traslato terra 55
ePset_BIMobjectScript - SEAT_COVER: Soft_Close_Plus; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): NEW ZERO NewFlush Vaso traslato terra 55; SKU (BO_prodsku): new-zero-newflush-vaso-traslato-terra-55; ManufacturName (BO_Manufac): Ceramica Catalano; BrandUrl (BO_brandurl): http://www.catalano.it/; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/ceramica-catalano/product/new-zero-newflush-vaso-traslato-terra-55; ProductDataUrl (BO_prodaturl): bimobject.com/ceramica-catalano/product/new-zero-newflush-vaso-traslato-terra-55; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Toilets; BimObjectCategoryCode (BO_bocat_code): toilets; IfcClassification (BO_ifcclas): Sanitary Terminal; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
